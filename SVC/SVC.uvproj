# Keil uVision project SVC.uvproj, settings and files
target SVC SIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: SVC
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/: startup_LPC17xx.s
  group System Code
    ./src/: system_LPC17xx.c uart_polling.h uart_polling.c printf.h printf.c
  group Source Code
    ./src/: main_svc.c
  group Kernel Code
    ./src/: HAL.c k_rtx.h rtx.h rtx.c
target SVC RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: SVC
  c flags: Optim=1
  c define: DEBUG_0
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
