# Keil uVision project rtos.uvproj, settings and files
target RTOS SIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtos
  c flags: Optim=1
  c define: DEBUG_0 DEBUG_HOTKEYS DEBUG_DEMO
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/: startup_LPC17xx.s
  group System Code
    ./src/: system_LPC17xx.c uart_polling.h uart_polling.c uart_irq.h uart_irq.c printf.h printf.c main_svc.c timer.h timer.c node.h list.h list.c queue.h queue.c string.h string.c
  group Kernel Code
    ./src/: HAL.c rtos.h k_rtos.h k_rtos_init.h k_rtos_init.c k_memory.h k_memory.c k_process.h k_process.c k_system_proc.h k_system_proc.c k_usr_proc.h k_usr_proc.c
  group User Code
    ./src/: usr_test_proc.h usr_test_proc.c
target RTOS RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: rtos
  c flags: Optim=1
  c define: DEBUG_0
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
